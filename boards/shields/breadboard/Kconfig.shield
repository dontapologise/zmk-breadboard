## config/boards/shields/breadboard/Kconfig.defconfig
```kconfig
if SHIELD_BREADBOARD

config ZMK_KEYBOARD_NAME
    default "breadboard"
    
CONFIG_ZMK_BLE_EXPERIMENTAL_CONN=y

endif
```
